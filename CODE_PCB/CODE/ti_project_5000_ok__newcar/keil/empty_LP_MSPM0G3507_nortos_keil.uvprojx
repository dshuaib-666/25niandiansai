# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\..\..\..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\..\..\..\..\..\source;..\BSP;..\..\ti_project;..\ti;..\BSP\OLED;..\..\..\tools\keil;..\..\ti_project_5000;..\..\ti_project_5000_ok;..\..\ti_project_5000_ok_35s;..\..\ti_project_5000_ok__newcar;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c
    ./: startup_mspm0g350x_uvision.s
    ../BSP/: CSZ_ALL.c CSZ_ALL.h YUNTAI_COUNTER.c YUNTAI_COUNTER.h
  group BSP
    ../BSP/: bsp_motor.c bsp_pid.c bsp_gyro.c bsp_beep.c bsp_iic.c bsp_beep.h bsp_gyro.h bsp_motor.h bsp_pid.h bsp_track.c bsp_track.h key.c key.h led.c led.h JY61P.c JY61P.h PID.c PID.h LASER.c LASER.h all.c all.h bsp_iic.h icm42688.c icm42688.h IMU.c IMU.h BUJIN.c BUJIN.h TEST.c TEST.h MY_USART_DMA.c MY_USART_DMA.h K230.c K230.h
    ../BSP/OLED/: oled.c oled.h oledfont.h
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c dl_sysctl_mspm0g1x0x_g3x0x.c
